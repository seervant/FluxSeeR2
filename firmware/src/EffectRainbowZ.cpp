#include "Effects.h"
#include "Config.h"
#include "LedGeometry.h"
#include "Params.h"
#include <math.h>

// ============================================================================
// ЭФФЕКТ 2 — ДИНАМИЧЕСКАЯ Z-РАДУГА
//
// Идея: вся лампа разворачивается в одну непрерывную «ленту» по поверхности:
//
//   ряд матрицы y = 0 (низ цилиндра) ... y = 15 (верх) -> внешнее кольцо
//   верхнего диска ... центральное кольцо диска.
//
//   s(ряд)    = y                                              (0..15)
//   s(кольцо) = MATRIX_HEIGHT + (DISK_RING_COUNT - 1 - кольцо)  (16..23)
//
// По этой ленте бежит спектральный градиент:
//
//   hue(s) = phase - s * delta
//
//   delta  — шаг оттенка на шаг пути. Задаётся параметром «Масштаб»:
//            чем больше масштаб, тем шире видимая часть спектра (больше
//            оттенков помещается на всю лампу). При максимуме (32) на всю
//            лампу приходится ровно один полный круг оттенков,
//            при минимуме (1) — почти ровный цвет.
//   phase  — общий сдвиг радуги; растёт со значением «Скорость».
//
// Направление (по ТЗ, знак скорости):
//   скорость > 0: цилиндр — снизу вверх, диск — от внешних колец к центру;
//   скорость < 0: цилиндр — сверху вниз, диск — от центра к внешним кольцам.
//
// ТЗ: «Эффект должен выглядеть как единая анимация на боковой и верхней
// части светильника» — здесь это буквально: один и тот же градиент
// переходит с цилиндра на диск через верхний край, оттенки соседних
// рядов и колец отличаются ровно на один шаг.
// ============================================================================

// ---------------------------------------------------------------------------
// Оттенок 0..255 с нормализацией отрицательных значений
// ---------------------------------------------------------------------------
static inline uint8_t hueWrap(float hue) {
  float h = fmodf(hue, 256.0f);
  if (h < 0.0f) h += 256.0f;
  return (uint8_t)h;
}

// ---------------------------------------------------------------------------
// Основной рендер
// ---------------------------------------------------------------------------
void renderEffect_RainbowZ() {
  const uint8_t eff = EFFECT_RAINBOW_Z;

  // --- Параметры ---
  uint8_t scaleParam = paramsFindByKind(eff, PK_SCALE);
  uint8_t speedParam = paramsFindByKind(eff, PK_SPEED);

  int16_t scale = (scaleParam != 0xFF) ? paramsValue(eff, scaleParam) : 16;
  int16_t speed = (speedParam != 0xFF) ? paramsValue(eff, speedParam) : 8;
  if (scale < 1)  scale = 1;
  if (scale > 32) scale = 32;

  // --- Время кадра ---
  // Фаза считается от реального времени, поэтому скорость не зависит от
  // частоты перерисовки.
  uint32_t now = millis();
  static uint32_t lastMs = 0;
  uint32_t dtMs = (lastMs == 0) ? 0 : (now - lastMs);
  lastMs = now;
  if (dtMs > 100) dtMs = 100;   // после возврата к эффекту не дёргаем радугу

  // --- Фаза радуги ---
  static float phase = 0.0f;
  phase += (float)speed * RAINBOW_Z_HUE_PER_SPEED * (float)dtMs / 1000.0f;
  phase = fmodf(phase, 256.0f);
  if (phase < 0.0f) phase += 256.0f;

  // --- Шаг оттенка: ширина видимой части спектра ---
  float span  = RAINBOW_Z_SPAN_STEP * (float)scale;   // ширина видимого спектра
  float delta = span / (float)RAINBOW_Z_PATH_LEN;    // оттенков на шаг пути

  // --- Боковая матрица: спектр по высоте ---
  for (uint8_t y = 0; y < MATRIX_HEIGHT; y++) {
    CRGB c = CHSV(hueWrap(phase - (float)y * delta), 255, 255);
    for (uint8_t x = 0; x < MATRIX_WIDTH; x++) {
      sideSet(x, y, c);
    }
  }

  // --- Верхний диск: те же зоны спектра, но по радиусу ---
  for (uint8_t ring = 0; ring < DISK_RING_COUNT; ring++) {
    float s = (float)(MATRIX_HEIGHT + (DISK_RING_COUNT - 1 - ring));
    CRGB c = CHSV(hueWrap(phase - s * delta), 255, 255);

    uint8_t n = diskRingSize(ring);
    for (uint8_t seg = 0; seg < n; seg++) {
      diskSet(ring, seg, c);
    }
  }
}
